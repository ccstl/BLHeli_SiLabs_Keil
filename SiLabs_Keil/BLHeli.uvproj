# Keil uVision project BLHeli.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F850-GU/IU Silicon Labs
  cpu: IRAM(0x00-0xFF) XRAM(0x00-0xFF) IROM(0x0000-0x1FFF) CLOCK(25000000)
  output: BLHeli +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BLHeli.asm
